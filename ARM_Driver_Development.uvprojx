# Keil uVision project ARM_Driver_Development.uvprojx, settings and files
target Peripheral Driver Code (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM_Driver_Development
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\Keil\TM4C_DFP\1.1.0\Device\Include\TM4C123
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Driver
    ./: hal_gpio_driver.h hal_spi_driver.h hal_i2c_driver.h hal_gpio_driver.c hal_spi_driver.c hal_i2c_driver.c
  group Application
    ./: main.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
